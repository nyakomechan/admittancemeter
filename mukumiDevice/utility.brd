# Repository nyakomechan/admittancemeter (continued)

## EAGLE design mukumiDevice/mukumi_ad9834_wearable.brd (continued)

Parts:
AD633_1, AD633_2, AD633_3: AD835; SO08
C5, C6, C7, C8, C29, C30: C-EUC0805; C0805
C,IC2A1, C,IC2A6, C,IC2A11, C,IC2A12, C,IC2A13, C,IC2A14, C,IC2A15, C,IC2A16, C,IC2A17, C,IC2A18: 0.1u; C0402
IC4: TL072D; SO08
IC4B6,2, IC4B6,3, IC4B6,4, IC4B6,5, IC4B6,6, IC4B6,7, IC4B6,8, IC4B6,9, IC4B6,10, IC4B6,11, IC4B6,12, IC4B6,13: 560a; R0402
U$11: NJM074V; TSSOP14

Connections:
+5V: AD633_1.6 (VP), AD633_2.6 (VP), AD633_3.6 (VP), C,IC2A1.1, C,IC2A6.1, C,IC2A11.1, C,IC2A15.1, C,IC2A17.1, IC4.8 (V+), U$11.4 (V+); also elsewhere on the board
-5V: AD633_1.3 (VN), AD633_2.3 (VN), AD633_3.3 (VN), C,IC2A12.2, C,IC2A13.2, C,IC2A14.2, C,IC2A16.2, C,IC2A18.2, IC4.4 (V-), U$11.11 (V-); also elsewhere on the board
COS: AD633_2.1 (Y1); also elsewhere on the board
GND: AD633_1.2 (Y2), AD633_1.4 (Z), AD633_1.7 (X2), AD633_2.2 (Y2), AD633_2.4 (Z), AD633_2.7 (X2), AD633_3.2 (Y2), AD633_3.4 (Z), AD633_3.7 (X2), C6.1, C7.1, C30.1, C,IC2A1.2, C,IC2A6.2, C,IC2A11.2, C,IC2A12.1, C,IC2A13.1, C,IC2A14.1, C,IC2A15.2, C,IC2A16.1, C,IC2A17.2, C,IC2A18.1, IC4B6,8.1, IC4B6,9.1, IC4B6,12.1; also elsewhere on the board
unnamed: C6.2, IC4B6,5.2, U$11.6 (-IN)
unnamed: C7.2, IC4B6,3.2, U$11.9 (-IN)
unnamed: C5.1, IC4B6,4.2, IC4B6,5.1
unnamed: AD633_1.5 (W), U$11.13 (-IN)
unnamed: C8.2, IC4B6,2.2, IC4B6,3.1
unnamed: IC4.1 (OUT), IC4B6,6.1, IC4B6,13.2
unnamed: IC4B6,8.2, IC4B6,10.1, U$11.12 (+IN)
unnamed: C30.2, IC4.6 (-IN), IC4B6,7.2
unnamed: IC4B6,9.2, IC4B6,11.1, U$11.3 (+IN)
unnamed: AD633_2.5 (W), U$11.2 (-IN)
unnamed: IC4B6,2.1, IC4B6,10.2, U$11.14 (OUT)
unnamed: IC4B6,4.1, IC4B6,11.2, U$11.1 (OUT)
unnamed: C29.1, IC4B6,6.2, IC4B6,7.1
unnamed: AD633_3.5 (W), IC4.2 (-IN)
unnamed: IC4.3 (+IN), IC4B6,12.2, IC4B6,13.1
SIG: AD633_1.8 (X1), AD633_2.8 (X1); also elsewhere on the board
SIG*COS: C5.2, U$11.5 (+IN), U$11.7 (OUT); also elsewhere on the board
SIG*SIN: C8.1, U$11.8 (OUT), U$11.10 (+IN); also elsewhere on the board
SIN: AD633_1.1 (Y1), AD633_3.1 (Y1), AD633_3.8 (X1); also elsewhere on the board
SIN*SIN: C29.2, IC4.5 (+IN), IC4.7 (OUT); also elsewhere on the board

Parts:
ATMEGA328: ATMEGA328P-AU; QFP80P900X900X120-32N
C51, C52: 0.1u; C0402
JP3: PINHD-2X3; 2X03
R1: R-EU_R0402; R0402
SJ1, SJ2: SJ
SV2: MA06-1

Connections:
3.3VMC: JP3.2
CS: ATMEGA328.10 (PD6)
DTR: C51.1, SV2.1
GND: ATMEGA328.3 (GND_2), ATMEGA328.5 (GND_3), ATMEGA328.21 (GND), C52.2, JP3.6, SV2.6; also elsewhere on the board
IO_UPDATE: ATMEGA328.11 (PD7)
MASTER_RESET: ATMEGA328.9 (PD5)
unnamed: ATMEGA328.29 (PC6), C51.2, JP3.5, R1.1
unnamed: ATMEGA328.17 (PB5), JP3.3, SJ1.2
unnamed: ATMEGA328.16 (PB4), JP3.1
unnamed: ATMEGA328.15 (PB3), JP3.4, SJ2.2
RXD_MC: ATMEGA328.30 (PD0), SV2.3
SCLK: SJ1.1; also elsewhere on the board
SDATA: SJ2.1; also elsewhere on the board
SIG*COS: ATMEGA328.24 (PC1); also elsewhere on the board
SIG*SIN: ATMEGA328.23 (PC0); also elsewhere on the board
SIN*SIN: ATMEGA328.25 (PC2); also elsewhere on the board
TXD_MC: ATMEGA328.31 (PD1), SV2.2

Parts:
C9, C10, C13, C32, C33, C34, C35: 0.1u; C0402
C14, C36: 0.01u; C0402
C16, C17, C20, C21: 20p; C0402
C26, C27, C28, C31: 10u; C0402
R2, R18: 6.8k; R0402
R4, R5, R12, R14, R15, R19: 10k; R0402
R6, R7, R8, R9: 200; R0402
U1, U2: AD9834; TSSOP20
U$8: SIT8002B; SOT25

Connections:
3.3V_DDS: C14.2, C26.1, C31.1, C36.1, U1.4 (AVDD), U2.4 (AVDD); also elsewhere on the board
AGND: C9.1, C10.2, C16.2, C17.2, C20.2, C21.2, C26.2, C31.2, C33.2, C35.1, R2.1, R12.2, R14.1, R18.2, U1.18 (AGND), U2.18 (AGND); also elsewhere on the board
DDS_OUT1: C16.1, R9.2, U2.19 (IOUT); also elsewhere on the board
DDS_OUT1B: C21.1, R6.2, U2.20 (IOUTB)
DDS_OUT2: C20.1, R7.2, U1.19 (IOUT); also elsewhere on the board
DDS_OUT2B: C17.1, R8.2, U1.20 (IOUTB)
FSYNC1: U2.15 (FSYNC)
FSYNC2: U1.15 (FSYNC)
GND: C13.2, C27.2, C28.2, C32.2, C34.1, R4.2, R5.2, R6.1, R7.1, R8.1, R9.1, R15.2, R19.2, U1.7 (DGNG), U2.7 (DGNG), U$8.1 (GND); also elsewhere on the board
unnamed 31: U1.8 (MCLK), U2.8 (MCLK), U$8.5 (OUT); also elsewhere on the board
unnamed: C10.1, U2.2 (REFOUT)
unnamed: C13.1, U1.6 (CAP/2.5V)
unnamed: C33.1, R18.1, U1.1 (FS_ADJUST)
unnamed: C34.2, U2.6 (CAP/2.5V)
unnamed: R19.1, U2.9 (FSELECT)
unnamed: R4.1, U1.9 (FSELECT)
unnamed: R14.2, U1.11 (RESET)
unnamed: R15.1, U1.10 (PSELECT)
unnamed: R12.1, U2.11 (RESET)
unnamed: C9.2, R2.2, U2.1 (FS_ADJUST)
unnamed: R5.1, U2.10 (PSELECT)
unnamed: C35.2, U1.2 (REFOUT)
unnamed: C36.2, U1.3 (COMP)
unnamed: C14.1, U2.3 (COMP)
SCLK: U1.14 (SCLK), U2.14 (SCLK); also elsewhere on the board
SDATA: U1.13 (SDATA), U2.13 (SDATA); also elsewhere on the board

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
Board: 4 copper layers, 54.0 x 90.0 mm, 136 parts (52 on the bottom side), 90 nets.

Other parts of the board:
U$9: SG710

Their connections:
GND: U$9.P$2; also elsewhere on the board
unnamed 31: U$9.P$3; also elsewhere on the board

## EAGLE design mukumiDevice/power_comtroller.brd

Board: 2 copper layers, 110.5 x 56.8 mm, 44 parts (0 on the bottom side), 22 nets.

Parts:
0: 1k; 0204/7
C1, C2, C3, C4, C5, C6, C11, C12: 153CLV-0810
C7, C8: 10u; E1,8-4
C16, C17, C18, C19, C20, C21, C22, C23: D/7343-31W
C24, C25: 0.33; C025-024X044
IC1: LM317MSTT3; SOT223
JP2: 1X04
JP4, JP5: 1X03
L1: 0204/5
L2: CDRH125
L4, L5: CDRH6D28; CDRH6D
L6, L7, L8: CDRH4D18
L9: L2825P
R1: 1k; 0204/7
SJ4, SJ5, SJ6, SJ8, SJ9, SJ12, SJ17, SJ18, SJ19: SJ
U$1: NJM2884; SOT89-5

Connections:
1.8V: C8.+, IC1.4
3.3V_MC: C7.+, C25.1, IC1.3, U$1.4
+BATTERY: JP2.1, SJ5.1, SJ17.1, SJ18.1, SJ19.1
+REG: JP2.2, SJ8.1, SJ12.1
-REG: JP2.4, SJ6.1, SJ9.1
DGND: C7.-, C8.-, C24.2, C25.2, IC1.1, SJ4.2, U$1.2
F1: C5.+, C22.+, L6.1, SJ12.2
F1-: C2.+, C16.+, L8.1, SJ9.2
F2: C12.+, C20.+, L5.1, SJ8.2
F2-: C4.+, C18.+, L4.1, SJ6.2
GND: C1.-, C2.-, C3.-, C4.-, C5.-, C6.-, C11.-, C12.-, C16.-, C17.-, C18.-, C19.-, C20.-, C21.-, C22.-, C23.-, JP2.3, JP4.2, JP5.2, SJ4.1
unnamed: C6.+, C23.+, JP5.1, L6.2
unnamed: R1.2, U$1.1
unnamed: C1.+, C19.+, JP4.1, L4.2
unnamed: L2.1, SJ5.2
unnamed: C3.+, C17.+, JP5.3, L8.2
unnamed: 0.2, C24.1, R1.1, U$1.5
unnamed: C11.+, C21.+, JP4.3, L5.2
unnamed: 0.1, L1.2, L2.2, L7.2, L9.2
unnamed: L7.1, SJ17.2
unnamed: L9.1, SJ18.2
unnamed: L1.1, SJ19.2

## EAGLE design mukumiDevice/mukumi_ad9958.brd

Parts:
C,IC2A2, C,IC2A4, C,IC2A5, C,IC2A7, C,IC2A8, C,IC2A9, C,IC2A10: 0.1u; C0402
C,IC2A3: 4.7u; C2012
C,IC4A1,1: 0.47u; C2012
CIC2B1: 4.7u; C2012
IC1A1, IC1A1,1, IC1B1, IC1B2: 1k; R0402
IC1A3'1, IC4A1, IC4A2,2, IC4B2: 560; R0402
IC1B6,1: 2k; R0402
IC2A1,1, IC2A4, IC2B2, IC2B6,1: 5.1k; R0402
IC2A3, IC2A3,2, IC2B1, IC2B3: 20k; R0402
IC3A2, IC3B1: 56; R0402
IC4B1: 62a; R0402
IC4B6,1: 560a; R0402
PAD1: hi; 1,6/0,8
PAD2: han; 1,6/0,8
PAD3: 1,6/0,8
PAD6: sa; 1,6/0,8
R25, R27, R31, R32, R33, R34, R35, R36: 100; R0402
SV1: MA05-1
U$3, U$7, U$10: NJM074V; TSSOP14
U$4: PVZ3A

Connections:
+5V: C,IC2A2.1, C,IC2A4.1, C,IC2A5.1, U$3.4 (V+), U$7.4 (V+), U$10.4 (V+); also elsewhere on the board
-5V: C,IC2A8.2, C,IC2A9.2, C,IC2A10.2, U$3.11 (V-), U$7.11 (V-), U$10.11 (V-); also elsewhere on the board
A1: CIC2B1.1, IC2B6,1.1, U$10.7 (OUT)
CH0_IOUT_1: R31.1; also elsewhere on the board
CH0_IOUT_2: R32.1; also elsewhere on the board
CH1_IOUT1: R25.1; also elsewhere on the board
CH1_IOUT2: R27.1; also elsewhere on the board
COS: R35.2, U$3.14 (OUT); also elsewhere on the board
DENKYOKU1: SV1.4, U$7.12 (+IN)
DENKYOKU2: SV1.2, U$7.10 (+IN)
GND: C,IC2A2.2, C,IC2A4.2, C,IC2A5.2, C,IC2A7.1, C,IC2A8.1, C,IC2A9.1, C,IC2A10.1, IC1A1.1, IC1A3'1.1, IC1B1.2, IC2A3,2.2, IC2B3.2, IC4A1.2, IC4B1.1, IC4B2.1, R34.2, R36.2, SV1.3; also elsewhere on the board
I1: IC2A3,2.1, IC2A4.1, SV1.5, U$10.10 (+IN)
I2: IC2B2.1, IC2B3.1, SV1.1, U$10.5 (+IN)
unnamed: IC1A1.2, IC1A1,1.2, U$10.13 (-IN)
unnamed: IC1A1,1.1, IC2A3.2, PAD1.1, U$10.14 (OUT)
unnamed: IC2A1,1.2, IC2A3.1, U$10.9 (-IN)
unnamed: C,IC2A3.2, IC2A4.2
unnamed: IC2B1.1, IC2B6,1.2, U$10.6 (-IN)
unnamed: CIC2B1.2, IC2B2.2
unnamed: IC1B2.1, IC1B6,1.2, U$10.2 (-IN)
unnamed: IC2B1.2, PAD2.1, U$4.P$1, U$4.P$3, U$10.1 (OUT)
unnamed: IC1B6,1.1, U$4.P$2
unnamed: IC3A2.1, U$7.13 (-IN), U$7.14 (OUT)
unnamed: IC3B1.1, U$7.8 (OUT), U$7.9 (-IN)
unnamed: IC3B1.2, IC4A1.1, U$7.3 (+IN)
unnamed: IC3A2.2, IC4A2,2.1, U$7.2 (-IN)
unnamed: C,IC4A1,1.1, IC4A2,2.2, PAD6.1, U$7.1 (OUT)
unnamed: C,IC4A1,1.2, IC4B2.2, U$7.6 (-IN)
unnamed: C,IC2A3.1, IC2A1,1.1, U$10.8 (OUT)
unnamed: IC1B1.1, U$10.3 (+IN)
unnamed: IC4B1.2, IC4B6,1.1, U$7.5 (+IN)
unnamed: C,IC2A7.2, IC1A3'1.2, U$3.8 (OUT), U$3.9 (-IN), U$10.12 (+IN)
unnamed: IC1B2.2, U$3.6 (-IN), U$3.7 (OUT)
unnamed: R25.2, R36.1, U$3.13 (-IN)
unnamed: R27.2, R35.1, U$3.12 (+IN)
unnamed: R31.2, R34.1, U$3.2 (-IN)
unnamed: R32.2, R33.1, U$3.3 (+IN)
SIG: IC4B6,1.2, PAD3.1, U$7.7 (OUT); also elsewhere on the board
SIN: R33.2, U$3.1 (OUT), U$3.5 (+IN), U$3.10 (+IN); also elsewhere on the board

Parts:
C1, C2, C3, C4: CPOL-EU153CLV-0807; 153CLV-0807
C11, C12, C15, C42: C-EUC0805; C0805
C18, C19, C24: C-EUC0402; C0402
C25: C-EUC1206; C1206
JP2: PINHD-1X4; 1X04
SJ4: SJ
U$1, U$2: D62LCB
U$5, U$6: ADP3338; SOT223

Connections:
3.3V_DDS: C19.1, U$5.2 (OUT); also elsewhere on the board
3.3V_MC: C25.1, U$6.2 (OUT); also elsewhere on the board
+5V: C1.+, C12.1, U$1.P$2; also elsewhere on the board
+BATTERY: C18.1, C24.1, JP2.1, U$5.3 (IN), U$6.3 (IN)
+REG: C4.+, C11.1, JP2.2, U$1.P$1
-5V: C3.+, C42.1, U$2.P$2; also elsewhere on the board
-REG: C2.+, C15.1, JP2.4, U$2.P$1
DGND: C24.2, C25.2, SJ4.2, U$6.1 (GND); also elsewhere on the board
GND: C1.-, C2.-, C3.-, C4.-, C11.2, C12.2, C15.2, C18.2, C19.2, C42.2, JP2.3, SJ4.1, U$5.1 (GND); also elsewhere on the board

Parts:
AD633_1, AD633_2, AD633_3: AD835; SO08
C5, C6, C7, C8, C29, C30: C-EUC0805; C0805
C,IC2A1, C,IC2A6, C,IC2A11, C,IC2A12, C,IC2A13, C,IC2A14, C,IC2A15, C,IC2A16, C,IC2A17, C,IC2A18: 0.1u; C0402
IC4: TL072D; SO08
IC4B6,2, IC4B6,3, IC4B6,4, IC4B6,5, IC4B6,6, IC4B6,7, IC4B6,8, IC4B6,9, IC4B6,10, IC4B6,11, IC4B6,12, IC4B6,13: 560a; R0402
PAD4, PAD5, PAD7, PAD11, PAD12, PAD13, PAD14, PAD15, PAD16: 1,6/0,8
U$11: NJM074V; TSSOP14

Connections:
+5V: AD633_1.6 (VP), AD633_2.6 (VP), AD633_3.6 (VP), C,IC2A1.1, C,IC2A6.1, C,IC2A11.1, C,IC2A15.1, C,IC2A17.1, IC4.8 (V+), U$11.4 (V+); also elsewhere on the board
-5V: AD633_1.3 (VN), AD633_2.3 (VN), AD633_3.3 (VN), C,IC2A12.2, C,IC2A13.2, C,IC2A14.2, C,IC2A16.2, C,IC2A18.2, IC4.4 (V-), U$11.11 (V-); also elsewhere on the board
COS: AD633_2.1 (Y1); also elsewhere on the board
GND: AD633_1.2 (Y2), AD633_1.4 (Z), AD633_1.7 (X2), AD633_2.2 (Y2), AD633_2.4 (Z), AD633_2.7 (X2), AD633_3.2 (Y2), AD633_3.4 (Z), AD633_3.7 (X2), C6.1, C7.1, C30.1, C,IC2A1.2, C,IC2A6.2, C,IC2A11.2, C,IC2A12.1, C,IC2A13.1, C,IC2A14.1, C,IC2A15.2, C,IC2A16.1, C,IC2A17.2, C,IC2A18.1, IC4B6,8.1, IC4B6,9.1, IC4B6,12.1; also elsewhere on the board
unnamed: C6.2, IC4B6,5.2, U$11.6 (-IN)
unnamed: C7.2, IC4B6,3.2, U$11.9 (-IN)
unnamed: C5.1, IC4B6,4.2, IC4B6,5.1
unnamed: AD633_1.5 (W), PAD14.1, U$11.13 (-IN)
unnamed: C8.2, IC4B6,2.2, IC4B6,3.1
unnamed: IC4.1 (OUT), IC4B6,6.1, IC4B6,13.2, PAD13.1
unnamed: IC4B6,8.2, IC4B6,10.1, U$11.12 (+IN)
unnamed: C30.2, IC4.6 (-IN), IC4B6,7.2
unnamed: IC4B6,9.2, IC4B6,11.1, U$11.3 (+IN)
unnamed: AD633_2.5 (W), PAD15.1, U$11.2 (-IN)
unnamed: IC4B6,2.1, IC4B6,10.2, PAD11.1, U$11.14 (OUT)
unnamed: IC4B6,4.1, IC4B6,11.2, PAD12.1, U$11.1 (OUT)
unnamed: C29.1, IC4B6,6.2, IC4B6,7.1
unnamed: AD633_3.5 (W), IC4.2 (-IN), PAD16.1
unnamed: IC4.3 (+IN), IC4B6,12.2, IC4B6,13.1
SIG: AD633_1.8 (X1), AD633_2.8 (X1); also elsewhere on the board
SIG*COS: C5.2, PAD4.1, U$11.5 (+IN), U$11.7 (OUT); also elsewhere on the board
SIG*SIN: C8.1, PAD5.1, U$11.8 (OUT), U$11.10 (+IN); also elsewhere on the board
SIN: AD633_1.1 (Y1), AD633_3.1 (Y1), AD633_3.8 (X1); also elsewhere on the board
SIN*SIN: C29.2, IC4.5 (+IN), IC4.7 (OUT), PAD7.1; also elsewhere on the board

Parts:
C9, C10, C13, C16, C17, C20, C31, C32: 1n; C0402
C14, C21, C22, C23, C44: 220n; C0402
C33, C37, C40: 100u; C1206K
C34, C38, C41: 220n; C0402K
C35, C36, C39: 22u; C0805K
C45, C46: 1n; C0805
C47: 680p; C0402
C48: 0.33u; C1206
C49: 2.2u; C0402
IC3: LM317MSTT3; SOT223
L1, L2, L3: L-USL5038P; L5038P
Q1: CRYSTALHC49S; HC49/S
R2, R3, R4, R5, R6, R7, R8, R9, R10, R16, R17, R18, R19: 100; R0402
R11: 1k91; R0402
R29: 120; R0402
R30: 240; R0402
SV3: MA10-1
U$9: AD9958; QFN56

Connections:
3.3V_DDS: C48.1, IC3.3 (IN), L3.1; also elsewhere on the board
+3V3: C39.1, C40.1, C41.1, C44.1, L3.2, U$9.49 (DVDDIO)
CH0_IOUT_1: R16.1, U$9.9 (CH0_IOUT_N); also elsewhere on the board
CH0_IOUT_2: R17.1, U$9.8 (CH0_IOUT_P); also elsewhere on the board
CH1_IOUT1: R18.1, U$9.14 (CH1_IOUT_N); also elsewhere on the board
CH1_IOUT2: R19.1, U$9.13 (CH1_IOUT_P); also elsewhere on the board
CS: R3.1, SV3.9; also elsewhere on the board
GND: C9.2, C10.2, C13.2, C14.2, C16.2, C17.2, C20.2, C21.2, C22.2, C23.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C44.2, C45.1, C46.1, C47.2, C48.2, C49.2, R11.1, R29.1, SV3.1, U$9.6 (AGND), U$9.10 (AGND1), U$9.12 (AGND2), U$9.16 (AGND3), U$9.18 (AGND4), U$9.20 (AGND5), U$9.25 (AGND6), U$9.40 (P0), U$9.41 (P1), U$9.42 (P2), U$9.43 (P3), U$9.44 (DGND), U$9.56 (DGND1), U$9.EPAD (AGND7); also elsewhere on the board
IO_UPDATE: R2.1, SV3.10; also elsewhere on the board
MASTER_RESET: R9.1, SV3.3; also elsewhere on the board
unnamed: R9.2, U$9.3 (MASTER_RESET)
unnamed: R10.2, U$9.4 (PWR_DWN_CTL)
unnamed: R2.2, U$9.46 (IO_UPDATE)
unnamed: C49.1, IC3.4 (OUT), L1.1, L2.1, R30.2
unnamed: C46.2, Q1.1, U$9.22 (REFCLK_N)
unnamed: C45.2, Q1.2, U$9.23 (REFCLK_P)
unnamed: R8.2, U$9.53 (SDIO_3)
unnamed: R7.2, U$9.52 (SDIO_2)
unnamed: R6.2, U$9.51 (SDIO_1)
unnamed: R5.2, U$9.50 (SDIO_0)
unnamed: R4.2, U$9.48 (SCLK)
unnamed: R3.2, U$9.47 (#CS)
unnamed: R11.2, U$9.17 (DAC_RESET)
unnamed: C47.1, U$9.27 (LOOP_FILTER)
unnamed: IC3.1 (ADJ), R29.2, R30.1
PWR_DWN_CTL: R10.1, SV3.2
SCLK: R4.1, SV3.8; also elsewhere on the board
SDIO0: R5.1, SV3.7; also elsewhere on the board
SDIO1: R6.1, SV3.6
SDIO2: R7.1, SV3.5
SDIO3: R8.1, SV3.4
VCC: C9.1, C10.1, C13.1, C14.1, C21.1, C22.1, C23.1, C31.1, C32.1, C36.1, C37.1, C38.1, L2.2, R16.2, R17.2, R18.2, R19.2, U$9.5 (AVDD), U$9.7 (AVDD1), U$9.11 (AVDD2), U$9.15 (AVDD3), U$9.19 (AVDD4), U$9.21 (AVDD5), U$9.24 (CLK_MODE_SEL), U$9.26 (AVDD6), U$9.29 (AVDD7), U$9.30 (AVDD8), U$9.31 (AVDD9), U$9.33 (AVDD10), U$9.35 (AVDD11), U$9.36 (AVDD12), U$9.37 (AVDD13), U$9.39 (AVDD14)
VDD: C16.1, C17.1, C20.1, C33.1, C34.1, C35.1, L1.2, U$9.45 (DVDD), U$9.55 (DVDD1)

Parts:
C26, C27, C28: C-EUC2012; C2012
IC5: ATMEGA328-20P; DIL28-3
JP1: PINHD-2X3; 2X03
Q2: XTAL/S; QS
R23: R-EU_R2012; R2012
S2: DTSM-6
SJ1, SJ2, SJ3: SJ
SV2: MA06-1

Connections:
3.3V_MC: IC5.7 (VCC), IC5.20 (AVCC), JP1.2, R23.2; also elsewhere on the board
5V: SV2.4
CS: IC5.12 ((PCI22/AIN0OC0A)PD6); also elsewhere on the board
DGND: C26.1, C27.1, IC5.8 (GND), IC5.22 (AGND), JP1.6, S2.3, S2.4, SV2.6; also elsewhere on the board
DTR: C28.1, SV2.1
IO_UPDATE: IC5.13 ((PCI23/AIN1)PD7); also elsewhere on the board
MASTER_RESET: IC5.11 ((PCI21/T1/OC0B)PD5); also elsewhere on the board
unnamed: C28.2, IC5.1 (PC6(/RESET/PCI14)), JP1.5, R23.1, S2.1, S2.2
unnamed: IC5.19 ((PCI5/SCK)PB5), JP1.3, SJ3.1
unnamed: C26.2, IC5.10 (PB7(XTAL2/TOSC2/PCI7)), Q2.1
unnamed: C27.2, IC5.9 (PB6(XTAL1/TOSC1/PCI6)), Q2.2
unnamed: IC5.18 ((PCI4/MISO)PB4), JP1.1, SJ2.1
unnamed: IC5.17 ((PCI3/MOSI/OC2A)PB3), JP1.4, SJ1.1
RXD_MC: IC5.2 ((PCI16/RXD)PD0), SV2.3
SCLK: SJ3.2; also elsewhere on the board
SDIO0: SJ1.2; also elsewhere on the board
SIG*COS: IC5.24 ((PCI9/ADC1)PC1); also elsewhere on the board
SIG*SIN: IC5.23 ((PCI8/ADC0)PC0); also elsewhere on the board
SIN*SIN: IC5.25 ((PCI10/ADC2)PC2); also elsewhere on the board
TXD_MC: IC5.3 ((PCI17/TXD)PD1), SV2.2
