# Repository nyakomechan/admittancemeter (continued)

## EAGLE design mukumiDevice/mukumi_ad9958.brd (continued)

Board: 4 copper layers, 53.5 x 90.0 mm, 170 parts (59 on the bottom side), 99 nets.

## Commit log

2017-06-19 addAnalogPowerFilter
2017-06-20 removed arduino and layout brd
2017-06-20 removed arduino and layout board
2017-06-28 arduino with atmega328p
2017-06-29 散らばってたpower_comtrollerの整理
2017-06-29 ad9834版を作り始めた
2017-06-29 ad9834周りの部品の置き換え、整理
2017-06-30 AGNDとDGNDの接続の問題
2017-07-02 brdにdds配置・配線（未完）
2017-07-03 マイコンとオシレータ実装 あと電源周り配線
2017-07-04 mems発振器に変更と電源周り配線修正
2017-07-05 eagleによるバックアップファイルの削除
2017-08-07 arduino 修正
2017-08-09 DDSのAGND,GNDの間違いの修正
2017-08-12 brdの一部配線、フィルタなしの構成のsch,brd追加
2017-08-17 バックアップファイル
2017-08-19 レギュレータをnjm2884に変更と未配線部分の配線
2017-09-01 agnd,dgndのインダクタによる接続
2017-09-01 Revert "agnd,dgndのインダクタによる接続"
    This reverts commit 8ebf4f6ca6ba426166226e421df2150118e3df71.
2017-09-06 bNAMEの整理と部品名の整理
2017-09-21 パターンを太くしたバージョン追加、ベタパターン追加、ｐ板提供部品に合わせたコンデンサ部品サイズの変更、DDSのfsyncがつながっていなかったのを修正、テスト、調整用スルーホール追加
2017-09-22 電源パターンの調整、SIN,COSデバッグ用ビアの追加、インダクタの変更
    ガーバーファイル追加
2017-11-24 brd,schの修正,utility追加
2017-11-24 ジャック部の修正
2017-12-27 負電圧の信号を取るため、atmega328のPWM(analogWrite)とRCローパスを用いてVCC/2を生成し、それを抵抗(1.8kのやつ）で加算してからAD変換ポートにつなぐ
2018-04-03 コミットてすと
2018-04-03 オペアンプの加算回路
2018-04-11 装置回路図に加算回路の追加
2018-04-11 回路図のセラミックコンデンサから電解コンデンサへの置換、加算回路のvcc/2をdds電源からの生成へ変更、基板サイズ拡大
2018-04-12 brdに加算回路追加
2018-04-13 brdのacカップリングコンデンサを電解コンデンサへの置換
2018-04-16 adcを追加
2018-04-18 ACカップリングコンデンサをPMLCAPへ変更とadc通信用i2cパスにプルアップ抵抗の追加
2018-04-19 乗算器をAD865またはAD633に選択可能に
2018-04-20 抵抗の値調整 部品表の出力、P板用部品表の追加
2018-04-23 実装図（シルク面）の調整
2018-04-25 配線の調整
2018-05-01 加算回路で使用するオペアンプの電源の±が逆につながっていたのを修正
2018-05-11 部品表に0ohm抵抗が抜けていたのを訂正、メイン基板のサイズに合わせてユーティリティ基板のピンの位置、サイズの変更
2018-05-14 ユーティリティ基板の配線の調整とガーバーデータ出力
2018-05-25 P板からの指摘点を修正、ad633用ユーティリティ基板の作成
2018-05-25 ガーバーデータ修正
2018-06-11 DDS電源用コンデンサの部品型番等を修正
