# Repository nyakomechan/admittancemeter

## EAGLE design mukumiDevice/utility.brd

Parts:
CURRENT_OUT: STEREO3.5MM; 3.5MM
JP1, JP10, JP11: PINHD-1X5; 1X05
JP2, JP7: PINHD-1X6; 1X06
JP3: PINHD-1X8; 1X08
JP4: PINHD-1X2; 1X02
JP8: PINHD-1X4; 1X04
JP9: PINHD-1X1; 1X01
MESURE_VOL: STEREO3.5MM; 3.5MM
R1: R-EU_0204/5; 0204/5
R2: R-EU_0204/7; 0204/7

Connections:
+5V: JP4.1, JP8.4, JP10.1, JP10.4
+12V: JP8.3, JP11.1
-12V: JP8.1, JP11.5
DTR: JP2.6
GND1: JP2.1, JP2.2, JP4.2, JP7.4, JP10.3
GND2: JP8.2, JP11.2, JP11.3
unnamed: CURRENT_OUT.P$1, JP1.3, MESURE_VOL.P$1, R1.2, R2.1
unnamed: CURRENT_OUT.P$4, JP1.1
unnamed: CURRENT_OUT.P$3, JP1.5
unnamed: JP1.2, MESURE_VOL.P$4
unnamed: JP1.4, MESURE_VOL.P$3
unnamed: CURRENT_OUT.P$2, MESURE_VOL.P$2, R1.1
unnamed: CURRENT_OUT.P$5, MESURE_VOL.P$5, R2.2
RXD: JP2.5, JP7.2
SW: JP9.1, JP10.2, JP10.5
TXD: JP2.4, JP7.3
VCC: JP2.3, JP7.5

Board: 2 copper layers, 51.0 x 43.6 mm, 12 parts (3 on the bottom side), 16 nets.

## EAGLE design mukumiDevice/mukumi_ad9834_wearable_add_solid_pattern.brd

Parts:
C1, C11, C12, C22, C38, C41, C42: 0.1u; C0402
C2, C3, C4: 0.47u; PANASONIC_B
C23, C40: 4.7u; PANASONIC_B
C37, C39: 3p; C0402
IC6, IC7, IC8: NJM074V; TSSOP14
R13, R39, R40, R41: 560; R0402
R16, R26: 3.3k; R0402
R17, R22: 22k; R0402
R20: 680; R0402
R21, R24: 2.7k; R0402
R23: 360; R0402
R25, R27, R28: 1k; R0402
R29, R32, R33, R35: 20k; R0402
R30, R31, R34, R36: 5.1k; R0402
R37, R38: 56; R0402
R42: 62a; R0402
R43: 560a; R0402
SV1: MA05-1
VR1: PVZ3A

Connections:
+5V: C11.1, C22.1, C41.1, IC6.4 (V+), IC7.4 (V+), IC8.4 (V+); also elsewhere on the board
-5V: C12.2, C38.2, C42.2, IC6.11 (V-), IC7.11 (V-), IC8.11 (V-); also elsewhere on the board
A1: C40.+, IC7.7 (OUT), R30.1
AGND: C1.1, C11.2, C12.1, C22.2, C38.1, C41.2, C42.1, R13.1, R20.1, R21.2, R24.2, R25.2, R32.2, R35.2, R39.2, R41.1, R42.1, SV1.3; also elsewhere on the board
COS: C39.2, IC6.14 (OUT), R22.2; also elsewhere on the board
DDS_OUT1: C3.+; also elsewhere on the board
DDS_OUT2: C4.+; also elsewhere on the board
DENKYOKU1: IC8.12 (+IN), SV1.4
DENKYOKU2: IC8.10 (+IN), SV1.2
I1: IC7.10 (+IN), R35.1, R36.1, SV1.5
I2: IC7.5 (+IN), R31.1, R32.1, SV1.1
unnamed: IC6.3 (+IN), R21.1
unnamed: IC6.12 (+IN), R24.1
unnamed: IC7.13 (-IN), R20.2, R23.2
unnamed: IC7.14 (OUT), R23.1, R33.2
unnamed: IC7.9 (-IN), R33.1, R34.2
unnamed: C23.-, R36.2
unnamed: IC7.6 (-IN), R29.1, R30.2
unnamed: C4.-, R26.2
unnamed: C40.-, R31.2
unnamed: IC7.2 (-IN), R27.1, R28.2
unnamed: IC7.1 (OUT), R29.2, VR1.P$1, VR1.P$3
unnamed: R28.1, VR1.P$2
unnamed: IC8.13 (-IN), IC8.14 (OUT), R38.1
unnamed: IC8.8 (OUT), IC8.9 (-IN), R37.1
unnamed: IC8.3 (+IN), R37.2, R39.1
unnamed: IC8.2 (-IN), R38.2, R40.1
unnamed: C2.+, IC8.1 (OUT), R40.2
unnamed: C2.-, IC8.5 (+IN), R41.2
unnamed: C23.+, IC7.8 (OUT), R34.1
unnamed: IC7.3 (+IN), R25.1
unnamed: IC8.6 (-IN), R42.2, R43.1
unnamed: C1.2, IC6.8 (OUT), IC6.9 (-IN), IC7.12 (+IN), R13.2
unnamed: IC6.6 (-IN), IC6.7 (OUT), R27.2
unnamed: C3.-, R16.2
unnamed: C37.1, IC6.2 (-IN), R16.1, R17.1
unnamed: C39.1, IC6.13 (-IN), R22.1, R26.1
SIG: IC8.7 (OUT), R43.2; also elsewhere on the board
SIN: C37.2, IC6.1 (OUT), IC6.5 (+IN), IC6.10 (+IN), R17.2; also elsewhere on the board

Parts:
C18, C24: 0.33u; C0603
C19, C25: 2.2u; C0603
IC9, IC10: NJM2884; SOT89-5
JP2: PINHD-1X4; 1X04
L1: CDRH4D18
R10, R11: 1k; R0402

Connections:
3.3V_DDS: C25.1, IC10.4 (VOUT); also elsewhere on the board
3.3V_MC: C19.1, IC9.4 (VOUT); also elsewhere on the board
+5V: JP2.2; also elsewhere on the board
+BATTERY: C18.1, C24.1, IC9.5 (VIN), IC10.5 (VIN), JP2.1, R10.1, R11.1
-5V: JP2.4; also elsewhere on the board
AGND: C24.2, C25.2, IC10.2 (GND), L1.1; also elsewhere on the board
GND: C18.2, C19.2, IC9.2 (GND), JP2.3, L1.2; also elsewhere on the board
unnamed: IC9.1 (CE), R10.2
unnamed: IC10.1 (CE), R11.2

Parts:
C15, C47, C56, C57, C58, C59: CPOL-EUB; PANASONIC_B
C43, C44, C45, C46, C48, C49, C50, C53, C54, C55: 0.1u; C0402
D1, D2, D3, D4: DIODESOD-523; SOD-523
IC1, IC2, IC3: AD835; SO08
IC4: TL072D; SO08
IC5, IC14: NJM074V; TSSOP14
R44, R46, R47, R48, R50, R51, R52, R53, R54, R55, R56, R57, R58, R59, R60, R61, R62, R63, R64, R65, R66, R67, R68, R69, R70, R71, R72: 560a; R0402
R45, R49: 11k; R0402
SJ3, SJ4, SJ5: SJ

Connections:
3.3V_DDS: R64.2, R71.2; also elsewhere on the board
3.3V_MC: D2.K (C), D4.K (C); also elsewhere on the board
+5V: C43.1, C45.1, C48.1, C50.1, C54.1, IC1.6 (VP), IC2.6 (VP), IC3.6 (VP), IC4.8 (V+), IC5.4 (V+), IC14.11 (V-); also elsewhere on the board
-5V: C44.2, C46.2, C49.2, C53.2, C55.2, IC1.3 (VN), IC2.3 (VN), IC3.3 (VN), IC4.4 (V-), IC5.11 (V-), IC14.4 (V+); also elsewhere on the board
AGND: C15.-, C43.2, C44.1, C45.2, C46.1, C48.2, C49.1, C50.2, C53.1, C54.2, C55.1, C56.-, C58.-, D1.A, D3.A, IC1.2 (Y2), IC1.4 (Z), IC1.8 (X1), IC2.2 (Y2), IC2.4 (Z), IC2.8 (X1), IC3.2 (Y2), IC3.4 (Z), IC3.8 (X1), IC14.3 (+IN), IC14.5 (+IN), IC14.10 (+IN), IC14.12 (+IN), R44.1, R48.1, R52.1, R65.1, R72.1; also elsewhere on the board
COS: SJ5.1; also elsewhere on the board
COS_: IC2.1 (Y1), SJ5.2
unnamed: C56.+, IC5.5 (+IN), R51.2
unnamed: C58.+, IC5.10 (+IN), R47.2
unnamed: C57.+, R50.2, R51.1
unnamed: C59.+, R46.2, R47.1
unnamed: IC5.13 (-IN), R44.2, R45.1
unnamed: IC2.5 (W), R57.1
unnamed: IC5.3 (+IN), R57.2
unnamed: IC1.5 (W), R56.1
unnamed: IC5.12 (+IN), R56.2
unnamed: IC14.2 (-IN), R59.2, R60.2, R61.1
unnamed: IC14.6 (-IN), R62.2, R63.1
unnamed: IC14.1 (OUT), R61.2, R62.1
unnamed: IC14.13 (-IN), R66.2, R67.2, R68.1
unnamed: IC14.9 (-IN), R69.2, R70.1
unnamed: IC14.14 (OUT), R68.2, R69.1
unnamed: IC5.2 (-IN), R48.2, R49.1
unnamed: IC5.14 (OUT), R45.2, R46.1
unnamed: IC5.1 (OUT), R49.2, R50.1
unnamed: C15.+, IC4.5 (+IN), R55.2
unnamed: C47.+, R54.2, R55.1
unnamed: C47.-, IC4.6 (-IN), IC4.7 (OUT)
unnamed: IC3.5 (W), R58.1
unnamed: IC4.1 (OUT), R53.2, R54.1
unnamed: IC4.2 (-IN), R52.2, R53.1
unnamed: IC4.3 (+IN), R58.2
SIG: SJ3.1; also elsewhere on the board
SIG_: IC1.7 (X2), IC2.7 (X2), SJ3.2
SIN: SJ4.1; also elsewhere on the board
SIN_: IC1.1 (Y1), IC3.1 (Y1), IC3.7 (X2), SJ4.2
VCC/2: R59.1, R64.1, R65.2
VCC/22: R66.1, R71.1, R72.2

Parts:
ATMEGA328: ATMEGA328P-AU; QFP80P900X900X120-32N
C51, C52: 0.1u; C0402
JP1: PINHD-1X1; 1X01
JP3: PINHD-2X3; 2X03
R1: 10k; R0402
SJ1, SJ2: SJ
SV2: MA06-1

Connections:
3.3V_DDS: ATMEGA328.18 (AVCC); also elsewhere on the board
3.3V_MC: ATMEGA328.4 (VCC_2), ATMEGA328.6 (VCC), C52.1, JP3.2, R1.2, SV2.4; also elsewhere on the board
AGND: ATMEGA328.21 (GND); also elsewhere on the board
ANALOGSWITCH: ATMEGA328.11 (PD7), JP1.1; also elsewhere on the board
DTR: C51.1, SV2.1
FSYNC1: ATMEGA328.9 (PD5); also elsewhere on the board
FSYNC2: ATMEGA328.10 (PD6); also elsewhere on the board
GND: ATMEGA328.3 (GND_2), ATMEGA328.5 (GND_3), C52.2, JP3.6, SV2.5, SV2.6; also elsewhere on the board
unnamed: ATMEGA328.29 (PC6), C51.2, JP3.5, R1.1
unnamed: ATMEGA328.17 (PB5), JP3.3, SJ1.2
unnamed: ATMEGA328.16 (PB4), JP3.1
unnamed: ATMEGA328.15 (PB3), JP3.4, SJ2.2
RXD_MC: ATMEGA328.30 (PD0), SV2.3
SCLK: SJ1.1; also elsewhere on the board
SDATA: SJ2.1; also elsewhere on the board
SIN*SIN: ATMEGA328.25 (PC2)
TXD_MC: ATMEGA328.31 (PD1), SV2.2

Parts:
C9, C10, C13, C32, C33, C34, C35: 0.1u; C0402
C14, C36: 0.01u; C0402
C16, C17, C20, C21: 20p; C0402
C26, C27, C28, C31: 10u; C0402
IC11, IC12: AD9834; TSSOP20
IC13: SIT8002B; SOT25
R2, R18: 6.8k; R0402
R3: 1k; R0402
R4, R5, R12, R14, R15, R19: 10k; R0402
R6, R7, R8, R9: 200; R0402

Connections:
3.3V_DDS: C14.2, C26.1, C31.1, C36.1, IC11.4 (AVDD), IC12.4 (AVDD); also elsewhere on the board
3.3V_MC: C27.1, C28.1, C32.1, IC11.5 (DVDD), IC12.5 (DVDD), IC13.4 (VDD); also elsewhere on the board
AGND: C9.1, C10.2, C16.2, C17.2, C20.2, C21.2, C26.2, C31.2, C33.2, C35.1, IC11.18 (AGND), IC12.18 (AGND), R2.1, R6.1, R7.1, R8.1, R9.1, R18.2; also elsewhere on the board
ANALOGSWITCH: R3.2; also elsewhere on the board
DDS_OUT1: C16.1, IC11.19 (IOUT), R9.2; also elsewhere on the board
DDS_OUT1B: C21.1, IC11.20 (IOUTB), R6.2
DDS_OUT2: C20.1, IC12.19 (IOUT), R7.2; also elsewhere on the board
DDS_OUT2B: C17.1, IC12.20 (IOUTB), R8.2
FSYNC1: IC11.15 (FSYNC); also elsewhere on the board
FSYNC2: IC12.15 (FSYNC); also elsewhere on the board
GND: C13.2, C27.2, C28.2, C32.2, C34.1, IC11.7 (DGNG), IC11.12 (SLEEP), IC12.7 (DGNG), IC12.12 (SLEEP), IC13.1 (GND), R4.2, R5.2, R12.2, R14.1, R15.2, R19.2; also elsewhere on the board
unnamed: IC11.8 (MCLK), IC12.8 (MCLK), IC13.5 (OUT)
unnamed: C10.1, IC11.2 (REFOUT)
unnamed: C13.1, IC12.6 (CAP/2.5V)
unnamed: IC13.3 (OE), R3.1
unnamed: C33.1, IC12.1 (FS_ADJUST), R18.1
unnamed: C34.2, IC11.6 (CAP/2.5V)
unnamed: IC11.9 (FSELECT), R19.1
unnamed: IC12.9 (FSELECT), R4.1
unnamed: IC12.11 (RESET), R14.2
unnamed: IC12.10 (PSELECT), R15.1
unnamed: IC11.11 (RESET), R12.1
unnamed: C9.2, IC11.1 (FS_ADJUST), R2.2
unnamed: IC11.10 (PSELECT), R5.1
unnamed: C35.2, IC12.2 (REFOUT)
unnamed: C36.2, IC12.3 (COMP)
unnamed: C14.1, IC11.3 (COMP)
SCLK: IC11.14 (SCLK), IC12.14 (SCLK); also elsewhere on the board
SDATA: IC11.13 (SDATA), IC12.13 (SDATA); also elsewhere on the board

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
Board: 4 copper layers, 49.2 x 49.6 mm, 147 parts (77 on the bottom side), 102 nets.

## EAGLE design mukumiDevice/module180109/sum_mod.brd

Parts:
IC5: NJM074V; TSSOP14
JP1, JP2, JP3: PINHD-1X3; 1X03
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R44: 560a; R0402

Connections:
+5V: IC5.11 (V-), JP1.1
-5V: IC5.4 (V+), JP1.3
AGND: IC5.3 (+IN), IC5.5 (+IN), IC5.10 (+IN), IC5.12 (+IN), JP1.2, R6.1, R13.1
unnamed: IC5.13 (-IN), R7.2, R8.2, R9.1
unnamed: IC5.9 (-IN), R10.2, R11.1
unnamed: IC5.14 (OUT), R9.2, R10.1
unnamed: IC5.6 (-IN), R3.2, R4.1
unnamed: IC5.2 (-IN), R1.2, R2.1, R44.2
unnamed: IC5.1 (OUT), R2.2, R3.1
SIN: JP2.3, R1.1
SIN2: JP3.3, R8.1
SOUT: IC5.7 (OUT), JP2.1, R4.2
SOUT2: IC5.8 (OUT), JP3.1, R11.2
VCC: JP2.2, R5.2
VCC2: JP3.2, R12.2
VCC/2: R5.1, R6.2, R44.1
VCC/22: R7.1, R12.1, R13.2

Board: 2 copper layers, 12.0 x 27.0 mm, 18 parts (0 on the bottom side), 17 nets.

## EAGLE design mukumiDevice/mukumi_ad9834_wearable.brd

Parts:
C23, C40: 0.47u; C0805
C37, C39: 3p; C0402
C,IC2A2, C,IC2A4, C,IC2A5, C,IC2A7, C,IC2A8, C,IC2A9, C,IC2A10: 0.1u; C0402
C,IC2A3: 4.7u; C2012
C,IC4A1,1: 0.47u; C2012
CIC2B1: 4.7u; C2012
IC1A1, IC1A1,1, IC1B1, IC1B2: 1k; R0402
IC1A3'1, IC4A1, IC4A2,2, IC4B2: 560; R0402
IC1B6,1: 2k; R0402
IC2A1,1, IC2A4, IC2B2, IC2B6,1: 5.1k; R0402
IC2A3, IC2A3,2, IC2B1, IC2B3: 20k; R0402
IC3A2, IC3B1: 56; R0402
IC4B1: 62a; R0402
IC4B6,1: 560a; R0402
R16, R26: 3.3k; R0402
R17, R22: 22k; R0402
R21, R24: 2.7k; R0402
SV1: MA05-1
U$3, U$7, U$10: NJM074V; TSSOP14
U$4: PVZ3A

Connections:
+5V: C,IC2A2.1, C,IC2A4.1, C,IC2A5.1, U$3.4 (V+), U$7.4 (V+), U$10.4 (V+); also elsewhere on the board
-5V: C,IC2A8.2, C,IC2A9.2, C,IC2A10.2, U$3.11 (V-), U$7.11 (V-), U$10.11 (V-); also elsewhere on the board
A1: CIC2B1.1, IC2B6,1.1, U$10.7 (OUT)
AGND: R21.2, R24.2, SV1.3; also elsewhere on the board
COS: C39.2, R22.2, U$3.14 (OUT); also elsewhere on the board
DDS_OUT1: C23.1; also elsewhere on the board
DDS_OUT2: C40.1; also elsewhere on the board
DENKYOKU1: SV1.4, U$7.12 (+IN)
DENKYOKU2: SV1.2, U$7.10 (+IN)
GND: C,IC2A2.2, C,IC2A4.2, C,IC2A5.2, C,IC2A7.1, C,IC2A8.1, C,IC2A9.1, C,IC2A10.1, IC1A1.1, IC1A3'1.1, IC1B1.2, IC2A3,2.2, IC2B3.2, IC4A1.2, IC4B1.1, IC4B2.1; also elsewhere on the board
I1: IC2A3,2.1, IC2A4.1, SV1.5, U$10.10 (+IN)
I2: IC2B2.1, IC2B3.1, SV1.1, U$10.5 (+IN)
unnamed: R21.1, U$3.2 (-IN)
unnamed: IC1A1.2, IC1A1,1.2, U$10.13 (-IN)
unnamed: IC1A1,1.1, IC2A3.2, U$10.14 (OUT)
unnamed: R24.1, U$3.13 (-IN)
unnamed: IC2A1,1.2, IC2A3.1, U$10.9 (-IN)
unnamed: C,IC2A3.2, IC2A4.2
unnamed: IC2B1.1, IC2B6,1.2, U$10.6 (-IN)
unnamed: CIC2B1.2, IC2B2.2
unnamed: IC1B2.1, IC1B6,1.2, U$10.2 (-IN)
unnamed: IC2B1.2, U$4.P$1, U$4.P$3, U$10.1 (OUT)
unnamed: IC1B6,1.1, U$4.P$2
unnamed: IC3A2.1, U$7.13 (-IN), U$7.14 (OUT)
unnamed: IC3B1.1, U$7.8 (OUT), U$7.9 (-IN)
unnamed: IC3B1.2, IC4A1.1, U$7.3 (+IN)
unnamed: IC3A2.2, IC4A2,2.1, U$7.2 (-IN)
unnamed: C,IC4A1,1.1, IC4A2,2.2, U$7.1 (OUT)
unnamed: C,IC4A1,1.2, IC4B2.2, U$7.6 (-IN)
unnamed: C,IC2A3.1, IC2A1,1.1, U$10.8 (OUT)
unnamed: IC1B1.1, U$10.3 (+IN)
unnamed: IC4B1.2, IC4B6,1.1, U$7.5 (+IN)
unnamed: C,IC2A7.2, IC1A3'1.2, U$3.8 (OUT), U$3.9 (-IN), U$10.12 (+IN)
unnamed: IC1B2.2, U$3.6 (-IN), U$3.7 (OUT)
unnamed: C23.2, R16.2
unnamed: C37.1, R16.1, R17.1, U$3.3 (+IN)
unnamed: C39.1, R22.1, R26.1, U$3.12 (+IN)
unnamed: C40.2, R26.2
SIG: IC4B6,1.2, U$7.7 (OUT); also elsewhere on the board
SIN: C37.2, R17.2, U$3.1 (OUT), U$3.5 (+IN), U$3.10 (+IN); also elsewhere on the board

Parts:
C1, C2, C3, C4: CPOL-EU153CLV-0807; 153CLV-0807
C11, C12, C15, C42: C-EUC0805; C0805
C18, C19, C24, C25: C-EUC0402; C0402
JP2: PINHD-1X4; 1X04
U$1, U$2: D62LCB
U$5, U$6: ADP3338; SOT223

Connections:
3.3V_DDS: C19.1, U$5.2 (OUT); also elsewhere on the board
+5V: C1.+, C12.1, U$1.P$2; also elsewhere on the board
+BATTERY: C18.1, C24.1, JP2.1, U$5.3 (IN), U$6.3 (IN)
+REG: C4.+, C11.1, JP2.2, U$1.P$1
-5V: C3.+, C42.1, U$2.P$2; also elsewhere on the board
-REG: C2.+, C15.1, JP2.4, U$2.P$1
GND: C1.-, C2.-, C3.-, C4.-, C11.2, C12.2, C15.2, C18.2, C19.2, C24.2, C25.2, C42.2, JP2.3, U$5.1 (GND), U$6.1 (GND); also elsewhere on the board

Notices in the files:
parts and their libraries:
torex: Copyright (C) 2015, Bob Starr
inductor-sumida: Copyright (C) 2008, Bob Starr
PatternAgents-Cypress: License : http://creativecommons.org/licenses/by-sa/3.0
(Creative Commons 3.0)
